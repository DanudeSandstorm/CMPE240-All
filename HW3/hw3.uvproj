# Keil uVision project hw3.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: hw3
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  scatter file: .\Example.sct
  group Source Group 1
    ./: sieve.s
